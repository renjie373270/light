# Keil uVision project light.uvprojx, settings and files
target light (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: light
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CM3;.\FWlib\inc;.\mylib;.\user;.\FreeRTOS\include;.\FreeRTOS\port\MemMang;.\FreeRTOS\port\RVDS\ARM_CM3;.\FreeRTOS\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWlib
    ./FWlib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_systick.c stm32f10x_flash.c stm32f10x_iwdg.c misc.c
  group CM3
    ./CM3/: core_cm3.c system_stm32f10x.c
  group startup
    ./startup/: startup_stm32f10x_md.s
  group user
    ./user/: main.c stm32f10x_it.c
  group mylib
    ./mylib/: delay.c dog.c myflash.c usart1.c led.c ESP8266.c mystring.c
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c readme.txt stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ./FreeRTOS/port/MemMang/: heap_4.c
    ./FreeRTOS/port/RVDS/ARM_CM3/: port.c
